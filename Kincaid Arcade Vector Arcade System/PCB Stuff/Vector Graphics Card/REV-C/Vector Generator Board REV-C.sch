# EAGLE board Vector Generator Board REV-C (EAGLE 9.6.2), part 2 of 3
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
DX9  (via drill 0.35) (continued)
  Top 0.381: v172.59,142.88 v136.02,142.88
  Bottom 0.381: v136.02,142.88 136.02,125.35 134.11,123.44 5E.7 | v172.59,142.88 172.59,134.11 7E.3
DX10  (via drill 0.35)
  Top 0.381: v141.73,107.82 162.69,107.82 163.07,108.2 v167.26,108.2 | 7E.4 v167.26,129.54
  Bottom 0.381: v141.73,107.82 141.73,120.4 5E.9 | v167.26,129.54 v167.26,108.2
DX11  (via drill 0.35)
  Top 0.381: v143.64,137.16 163.83,137.16 163.83,131.44 166.88,128.4 173.36,128.4 174.5,127.25 7E.5
  Bottom 0.381: v143.64,137.16 143.64,130.3 5E.12
DX=0  (via drill 0.35)
  Top 0.381: v187.45,179.07 v158.88,179.07 v140.59,179.07 | 7B.4 174.88,236.22 178.69,232.41 v188.59,232.41 203.84,232.41 211.46,240.03 221.74,240.03 222.88,241.17 9B.13 | v88.01,278.13 61.72,278.13 60.58,276.99 1A.13 | v88.39,221.74 93.34,216.79 98.3,216.79 98.68,216.41 113.92,216.41 114.68,217.17 127.25,217.17 v127.64,216.79 | v136.4,212.98 v127.64,212.98
  Bottom 0.381: 6E.6 158.88,130.3 v158.88,179.07 | v187.45,179.07 188.59,180.21 v188.59,232.41 | v88.01,278.13 88.39,277.75 v88.39,221.74 | v127.64,212.98 v127.64,216.79 | v136.4,212.98 136.78,212.6 136.78,196.6 139.45,193.93 139.45,180.21 v140.59,179.07
DY0
  Top 0.381: 7F.2 137.92,99.06 134.11,95.25 5F.4
DY1  (via drill 0.35)
  Top 0.381: v143.64,80.39 144.02,80.77 165.74,80.77 v172.59,87.63
  Bottom 0.381: v143.64,80.39 143.64,91.44 137.92,91.44 134.11,87.63 5F.7 | v172.59,87.63 172.59,94.49 7F.3
DY2  (via drill 0.35)
  Top 0.381: v142.49,79.25 169.93,79.25 176.78,86.11 176.78,93.73 174.88,93.73 7F.4
  Bottom 0.381: 5F.9 142.49,84.2 v142.49,79.25
DY3
  Top 0.381: 7F.5 142.88,91.44 5F.12
DY4
  Top 0.381: 5G.4 134.49,60.2 139.45,60.2 140.21,60.96 145.54,60.96 153.16,68.58 169.55,68.58 7G.2
DY5
  Top 0.381: 5G.7 134.49,52.58 139.45,52.58 140.21,53.34 145.54,53.34 153.16,60.96 7G.3
DY6  (via drill 0.35)
  Top 0.381: v169.55,41.91 v141.73,41.91 | v169.55,58.29 174.5,58.29 7G.4
  Bottom 0.381: v141.73,41.91 141.73,49.53 5G.9 | v169.55,58.29 v169.55,41.91
DY7  (via drill 0.35)
  Top 0.381: v172.59,69.34 147.07,69.34 v143.64,65.91
  Bottom 0.381: 7G.5 172.59,57.91 v172.59,69.34 | v143.64,65.91 143.64,59.05 141.73,57.15 5G.12
DY8
  Top 0.381: 5H.4 134.11,24 136.4,24 137.92,22.48 137.92,16 138.3,15.62 138.3,10.67 176.02,10.67 177.55,12.19 177.55,27.81 174.88,27.81 7H.2
DY9  (via drill 0.35)
  Top 0.381: v176.78,37.72 v146.69,37.72
  Bottom 0.381: v146.69,37.72 146.69,15.24 140.21,15.24 139.45,16 139.45,16.38 134.11,16.38 5H.7 | v176.78,37.72 176.78,27.43 174.88,25.53 7H.3
DY10  (via drill 0.35)
  Top 0.381: v156.97,12.95 156.59,12.57 142.88,12.57 141.73,13.72 5H.9 | 7H.4 v156.97,22.86
  Bottom 0.381: v156.97,22.86 v156.97,12.95
DY11  (via drill 0.35)
  Top 0.381: v153.92,33.91 v172.59,33.91 | v152.02,21.72 141.73,21.72 5H.12
  Bottom 0.381: v172.59,33.91 172.59,22.48 174.5,20.57 7H.5 | v153.92,33.91 152.02,32 v152.02,21.72
DY/DX=0  (via drill 0.35)
  Top 0.381: v220.6,250.7 174.88,250.7 163.07,238.89 161.93,238.89 B6.12
  Bottom 0.381: 9B.11 220.6,238.51 v220.6,250.7
DY=0  (via drill 0.35)
  Top 0.381: 172.59,270.51 173.36,270.51 7A.4 | 172.59,270.51 160.02,270.51 160.02,275.08 160.78,275.84 161.16,275.84 161.93,276.61 6A.13 | v198.88,217.17 v167.26,217.17 | v204.98,232.03 205.36,232.41 216.41,232.41 222.5,238.51 222.88,238.51 9B.12 222.88,238.89 226.31,238.89 226.31,246.51 217.93,254.89 191.26,254.89 184.02,262.13 172.59,262.13 172.59,270.51
  Bottom 0.381: 6H.6 156.21,20.96 156.21,22.1 155.83,22.48 155.83,23.24 156.59,24 159.26,24 159.26,10.67 161.54,8.38 168.4,8.38 168.4,130.68 167.26,131.83 v167.26,217.17 | v198.88,217.17 198.88,222.5 204.98,228.6 v204.98,232.03
FRAMECOMPLETE  (via drill 0.35)
  Top 0.381: v57.53,274.32 1A.3 | 1H.19 59.06,34.29 v23.24,34.29 | v24.38,232.41 54.1,232.41 60.2,238.51 1B.12 | v23.24,173.74 v5.08,173.74
  Bottom 0.381: v57.53,274.32 57.53,241.55 1B.12 | v23.24,34.29 v23.24,173.74 24.38,174.88 v24.38,232.41 | v5.08,173.74 5.08,175.64 P1.D
GND  (via drill 0.35)  (1 unrouted)
  Top 0.381: R25.1 302.89,155.07 305.18,155.07 R35.2 | R31.1 280.03,175.26 R29.2 | C5.- 269.37,219.46 270.13,218.69 274.32,218.69 IC1.GND | IC2.GND 270.13,232.41 269.37,233.17 C6.- | C7.- 270.13,246.51 274.32,246.51 IC3.GND | IC4.GND 270.89,262.89 269.37,261.37 C8.+ | IC9.19 292.99,203.45 301.37,203.45 C35.2 301.75,203.45 307.85,203.45 C36.2 308.23,203.07 309.37,203.07 R34.1 | IC13.19 292.61,112.01 285.37,112.01 IC13.2 | C44.2 301.75,88.77 296.8,83.82 R40.2 280.8,83.82 278.89,81.91 R42.1 | C37.2 291.47,152.4 291.47,140.97 C39.2 | R36.1 302.89,62.48 305.18,62.48 R46.2 | C48.2 301.75,112.01 307.85,112.01 C49.2 308.23,111.63 309.37,111.63 R45.1 | C53.2 284.99,44.58 297.56,44.58 C47.2 299.09,45.72 316.99,45.72 318.13,44.58 C46.2 | T1.3 310.51,21.34 309.75,20.57 308.23,20.57 R22.1 | C9.+ 270.51,276.61 274.32,276.61 IC5.GND | v231.65,54.86 222.88,54.86 | 222.88,89.92 222.12,89.15 219.46,89.15 215.65,85.34 215.26,85.34 9F.8 | 5F.15 141.73,100.58 154.31,100.58 6F.2 | 217.93,120.78 215.26,120.78 9E.8 | v150.11,136.02 141.73,136.02 5E.15 | 222.88,161.16 217.93,156.21 9D.8 | v150.11,171.45 5D.15 | 222.88,196.98 223.27,197.36 225.93,197.36 230.5,201.93 10C.4 | 5C.15 141.73,206.88 154.31,206.88 6C.2 | v5.08,106.3 4.83,106.3
  Top 1.016: LED4.K LED6.A LED5.A LED3.K LED2.K LED1.K
  Top 2.54: P1.21 4.83,106.3 P1.22
  Bottom 0.381: C38.2 280.03,172.59 278.89,173.74 R31.1 | 296.42,181.74 296.42,175.26 R29.2 | 296.42,181.74 296.42,184.4 292.99,187.83 IC9.13 292.61,188.21 290.7,190.12 290.7,203.45 | 296.42,181.74 301.37,181.74 C31.2 301.75,181.36 302.89,180.21 R25.1 | 276.61,219.46 275.08,219.46 274.32,218.69 IC1.GND | 276.61,219.46 276.61,230.5 274.7,232.41 IC2.GND | 267.84,248.79 C7.- | 267.84,248.79 267.84,260.22 268.99,261.37 C8.+ | 267.84,248.79 267.84,234.7 268.99,233.55 C6.- | 284.99,205.74 284.99,203.45 IC9.2 285.37,203.45 290.7,203.45 | C29.2 313.18,174.12 313.18,199.26 R34.1 312.04,200.79 312.04,226.69 | 290.7,203.45 292.61,203.45 IC9.19 | 276.61,219.46 284.99,211.07 284.99,205.74 | 284.99,205.74 IC9.1 | 284.99,114.3 284.99,112.01 IC13.2 | 284.99,114.3 284.99,116.2 276.23,124.97 276.23,139.83 277.37,140.97 C40.2 | 284.99,114.3 IC13.1 | C51.2 278.89,76.2 278.89,81.91 R42.1 | R40.2 296.42,83.82 296.42,92.96 292.99,96.39 IC13.13 292.61,96.77 290.7,98.68 290.7,109.73 IC13.19 | C39.2 293.75,140.97 297.56,137.16 C34.2 297.94,137.16 301.37,133.73 301.37,118.87 302.89,117.35 302.89,113.16 301.75,112.01 C48.2 301.75,111.63 301.75,89.15 C44.2 | 313.18,82.68 314.33,81.53 C42.2 | 313.18,107.82 313.18,82.68 | R45.1 313.18,107.82 | 313.18,82.68 307.85,77.34 307.85,64.77 305.56,62.48 R46.2 | C50.2 288.8,62.1 288.8,50.67 289.94,49.53 C52.2 290.32,49.53 295.27,44.58 297.56,44.58 C47.2 297.94,44.2 301.37,40.77 301.37,33.15 304.04,30.48 | 304.04,26.67 302.89,25.53 Q2.1 | 304.04,30.48 304.04,26.67 | R24.1 305.56,16.76 307.85,19.05 307.85,20.19 R22.1 | 304.04,26.67 305.18,25.53 305.18,16.76 R24.1 | 4B.19 124.97,237.36 124.97,235.08 4B.18 125.35,235.08 130.18,235.08
  Bottom 0.381: 5H.15 141.35,29.34 136.02,29.34 136.02,41.53 134.87,42.67 134.87,48.39 134.11,49.15 5G.8 | 5G.15 141.35,64.77 135.64,70.48 135.64,76.2 C24.2 | 220.98,3.81 220.98,17.15 | v231.65,54.86 231.78,54.86 | 170.81,101.73 174.5,101.73 7F.1 | v150.11,136.02 150.5,136.02 | C33.2 316.23,135.25 316.23,129.54 | 316.23,129.54 318.52,127.25 X1.5 | v150.11,171.45 150.5,171.45 | 274.32,288.47 IC5.GND | X1.1 319.28,110.87 316.23,113.92 316.23,115.82 318.52,118.11 X1.3 | v5.08,106.3 5.08,106.68 | 305.56,3.81 305.56,16.38 R24.1 | 304.04,30.48 C28.2 | 313.18,107.82 314.71,109.35 314.71,128.02 316.23,129.54
  Bottom 1.016: 1H.10 48.9,12.7 | 48.9,3.81 48.9,12.7 | 48.9,12.7 48.9,35.56 | 48.9,35.56 48.9,46.99 | 48.9,46.99 48.9,69.85 | 48.9,69.85 48.9,76.2 | 48.9,76.2 48.9,82.55 | 48.9,82.55 48.9,105.41 | 48.9,105.41 48.9,152.4 | 48.9,152.4 48.9,175.26 | 48.9,175.26 48.9,189.23 | 48.9,189.23 48.9,212.09 | 48.9,212.09 48.9,218.44 | 48.9,218.44 48.9,228.6 | 48.9,228.6 48.9,264.16 | 48.9,264.16 48.9,288.47 | 48.9,46.99 1G.10 | 1F.10 48.9,82.55 | 1D.10 48.9,152.4 | 1C.10 48.9,189.23 | 1B.7 48.9,228.6 | 1A.7 48.9,264.16 | 2A.7 69.22,264.16 | 69.22,264.16 69.22,288.47 | 69.22,264.16 69.22,228.6 | 69.22,228.6 2B.7 | 69.22,228.6 69.22,218.44 | 69.22,218.44 69.22,212.09 | 69.22,212.09 69.22,189.23 | 69.22,189.23 2C.10 | 69.22,189.23 69.22,157.48 | 69.22,157.48 2D.7 | 69.22,157.48 69.22,140.97 | 69.22,140.97 2E.1 | 69.22,140.97 69.22,118.11 | 69.22,118.11 2E.10 | 69.22,118.11 69.22,86.36 | 69.22,86.36 2F.7 | 69.22,86.36 69.22,76.2 | 69.22,76.2 69.22,69.85 | 69.22,69.85 2G.1 | 69.22,69.85 69.22,46.99 | 69.22,46.99 2G.10 | 69.22,46.99 69.22,15.24 | 2H.7 69.22,15.24 | 69.22,15.24 69.22,3.81 | 48.9,35.56 1H.1 | 48.9,69.85 1G.1 | C20.2 48.9,76.2 | 69.22,76.2 C21.2 | 48.9,105.41 1F.1 | 48.9,175.26 1D.1 | 48.9,212.09 1C.1 | 48.9,218.44 C10.2 | 69.22,218.44 C11.2 | 69.22,212.09 2C.1 | 4B.12 106.05,222.25 | 106.05,222.25 106.05,218.44 | 106.05,218.44 106.05,213.36 | 106.05,213.36 106.05,199.39 | 106.05,199.39 106.05,175.26 | 106.05,175.26 106.05,163.83 | 106.05,163.83 106.05,139.7 | 106.05,139.7 106.05,128.27 | 106.05,128.27 106.05,92.71 | 106.05,92.71 106.05,91.44 | 106.05,91.44 106.05,76.2 | 106.05,76.2 106.05,68.58 | 106.05,68.58 106.05,57.15 | 106.05,57.15 106.05,33.02 | 106.05,33.02 106.05,21.59 | 106.05,21.59 106.05,3.81
  Bottom 1.016: 106.05,222.25 106.05,256.54 109.86,260.35 109.86,262.89 | 109.86,262.89 109.86,271.78 | 109.86,271.78 109.86,288.47 | 4A.8 109.86,262.89 | 4A.3 4A.4 113.67,271.78 | 113.67,271.78 4A.5 4A.6 | 113.67,271.78 109.86,271.78 | 106.05,218.44 C12.2 | 106.05,213.36 C13.2 | 106.05,199.39 3C.12 | 106.05,163.83 3D.12 | 3E.12 106.05,128.27 | 106.05,139.7 4D/4E.7 | 106.05,175.26 4C/4D.7 | 106.05,92.71 3F.12 | 106.05,91.44 C23.2 | 106.05,68.58 4F/4G.7 | 106.05,57.15 3G.12 | 106.05,33.02 4G/4H.7 | 106.05,21.59 3H.12 | 5H.8 130.18,13.97 | 130.18,13.97 130.18,3.81 | 130.18,13.97 130.18,49.53 | 130.18,49.53 130.18,76.2 | 130.18,76.2 130.18,85.09 | 130.18,85.09 130.18,120.65 | 130.18,120.65 130.18,156.21 | 130.18,156.21 130.18,191.77 | 130.18,191.77 130.18,218.44 | 130.18,218.44 130.18,228.6 | 130.18,228.6 130.18,235.08 130.18,264.16 | 130.18,264.16 130.18,288.47 | 130.18,264.16 5A.7 | 130.18,228.6 5B.7 | 130.18,218.44 C14.2 | 130.18,191.77 5C.8 | 130.18,156.21 5D.8 | 130.18,120.65 5E.8 | 130.18,85.09 5F.8 | 130.18,76.2 C24.2 | 130.18,49.53 5G.8 | 6H.8 150.5,13.97 | 150.5,13.97 150.5,3.81 | 150.5,13.97 150.5,49.53 | 150.5,49.53 150.5,76.2 | 150.5,76.2 150.5,85.09 | 150.5,85.09 150.5,95.25 | 150.5,95.25 150.5,100.33 | 150.5,100.33 150.5,120.65 | 150.5,120.65 150.5,136.02 150.5,156.21 | 150.5,156.21 150.5,171.45 150.5,191.77 | 150.5,191.77 150.5,201.93 | 150.5,201.93 150.5,207.01 | 150.5,207.01 150.5,218.44 | 150.5,218.44 150.5,228.6 | 150.5,228.6 150.5,264.16 | 6A.7 150.5,264.16 | 150.5,264.16 150.5,288.47 | 150.5,228.6 B6.7 | 150.5,218.44 C15.2 | 150.5,207.01 6C.2 | 150.5,201.93 6C.4 | 150.5,191.77 6C.8 | 150.5,156.21 6D.8 | 150.5,120.65 6E.8 | 150.5,85.09 6F.8 | 150.5,95.25 6F.4 | 150.5,100.33 6F.2
  Bottom 1.016: 150.5,49.53 6G.8 | 7H.7 170.81,15.24 | 170.81,15.24 170.81,3.81 | 170.81,15.24 170.81,50.8 | 170.81,50.8 170.81,76.2 | 170.81,76.2 170.81,86.36 | 170.81,86.36 170.81,101.73 170.81,121.92 | 170.81,121.92 170.81,157.48 | 170.81,157.48 170.81,193.04 | 170.81,193.04 170.81,208.28 | 170.81,208.28 170.81,218.44 | 170.81,218.44 170.81,228.6 | 170.81,228.6 170.81,264.16 | 170.81,264.16 170.81,288.47 | 170.81,264.16 7A.7 | 170.81,228.6 7B.7 | 170.81,218.44 C16.2 | 170.81,208.28 7C.1 | 170.81,193.04 7C.7 | 170.81,157.48 7D.7 | 170.81,121.92 7E.7 | 170.81,86.36 7F.7 | 170.81,76.2 C56.2 | 150.5,76.2 C55.2 | 170.81,50.8 7G.7 | 8G/8H.8 191.13,31.75 | 191.13,31.75 191.13,3.81 | 191.13,31.75 191.13,67.31 | 191.13,67.31 191.13,92.71 | 191.13,92.71 191.13,138.43 | 191.13,138.43 191.13,173.99 | 191.13,173.99 191.13,218.44 | 191.13,218.44 191.13,228.6 | 191.13,228.6 191.13,264.16 | 8A.7 191.13,264.16 | 191.13,264.16 191.13,288.47 | 191.13,228.6 8B.7 | 191.13,218.44 C17.2 | 191.13,173.99 8C/8D.8 | 191.13,138.43 8D/8E.8 | 191.13,92.71 C57.2 | 191.13,67.31 8F/8G.8 | 9H.8 211.46,13.97 | 211.46,13.97 211.46,3.81 | 211.46,13.97 211.46,49.53 | 211.46,49.53 211.46,76.2 | 211.46,76.2 211.46,85.09 | 211.46,85.09 211.46,95.25 | 211.46,95.25 211.46,120.65 | 211.46,120.65 211.46,156.21 | 211.46,156.21 211.46,191.77 | 211.46,191.77 211.46,201.93 | 211.46,201.93 211.46,218.44 | 211.46,218.44 211.46,228.6 | 211.46,228.6 211.46,264.16 | 211.46,264.16 211.46,288.47 | 211.46,264.16 9A.7 | 211.46,228.6 9B.7 | 211.46,218.44 C18.2 | 211.46,201.93 9C.4 | 211.46,191.77 9C.8 | 211.46,156.21 9D.8 | 211.46,120.65 9E.8 | 211.46,85.09 9F.8 | 211.46,95.25 9F.4 | 211.46,76.2 C58.2 | 211.46,49.53 9G.8 | 10H.8 231.78,13.97 | 231.78,13.97 231.78,3.81
  Bottom 1.016: 229.24,276.86 229.24,228.6 231.78,226.06 231.78,218.44 | 229.24,276.86 229.24,288.47 | 231.78,13.97 231.78,49.53 | 231.78,49.53 231.78,54.86 231.78,76.2 | 231.78,76.2 231.78,85.09 | 231.78,85.09 231.78,95.25 | 231.78,95.25 231.78,100.33 | 231.78,100.33 231.78,120.65 | 231.78,120.65 231.78,156.21 | 231.78,156.21 231.78,191.77 | 231.78,191.77 231.78,201.93 | 231.78,201.93 231.78,207.01 | 231.78,207.01 231.78,218.44 | LED4.K 229.87,277.5 229.24,276.86 | 231.78,218.44 C19.2 | 231.78,207.01 10C.2 | 231.78,201.93 10C.4 | 231.78,191.77 10C.8 | 231.78,156.21 10D.8 | 231.78,120.65 10E.8 | 231.78,85.09 10F.8 | 231.78,95.25 10F.4 | 231.78,100.33 10F.2 | 231.78,76.2 C59.2 | 231.78,49.53 10G.8 | 3B.7 89.54,228.6 89.54,264.16 | 89.54,264.16 89.54,287.2 90.81,288.47 | 3A.7 89.54,264.16 | C22.2 106.05,76.2
  Bottom 2.032: X2.2 315.34,237.75 307.34,245.75 C2.2 C1.2 306.78,249.63 X2.5 X2.6 | C4.+ 306.71,288.47 | C3.- 312.04,226.69 326.62,226.69
  Bottom 2.54: X1.5 326.62,126.59 | X1.3 326.31,118.67 | X2.6 326.21,253.59 326.62,254 | X2.5 325.9,249.63 326.62,248.92 | X2.2 325.61,237.75 326.62,238.76 | P1.21 4.83,106.68 P1.22
  Bottom 5.08: 326.62,118.97 326.62,126.59 326.62,226.69 326.62,238.76 326.62,248.92 326.62,254 326.62,277.27 315.42,288.47 306.71,288.47 274.32,288.47 229.24,288.47 211.46,288.47 191.13,288.47 170.81,288.47 150.5,288.47 130.18,288.47 109.86,288.47 90.81,288.47 69.22,288.47 48.9,288.47 26.21,288.47 15.24,277.5 15.24,106.68 | 326.62,118.97 326.31,118.67 | 326.62,118.97 326.62,11.02 319.4,3.81 305.56,3.81 231.78,3.81 220.98,3.81 211.46,3.81 191.13,3.81 170.81,3.81 150.5,3.81 130.18,3.81 106.05,3.81 69.22,3.81 48.9,3.81 24.77,3.81 15.24,13.34 15.24,106.68 | 4.83,106.68 5.08,106.68 15.24,106.68
  pour Bottom (isolate 0.381): 229.24,290.83 316.23,290.83 328.93,278.13 328.93,10.8 320.04,1.91 319.4,1.91 254,1.91 254,225.43 243.21,236.22 229.24,250.19 229.24,250.82
  pour Top (isolate 0.381): 229.24,286.38 314.33,286.38 324.49,276.23 328.93,271.78 328.93,269.24 328.93,10.8 328.93,10.16 320.04,1.27 254,1.27 254,225.43 229.24,250.19
  cutout Top: 275.59,266.06 293.37,266.06 293.37,254.63 275.59,254.63
  cutout Top: 275.59,269.24 275.59,280.03 293.37,280.03 293.37,268.61 275.59,268.61
HALTROTATE  (via drill 0.35)
  Top 0.381: v111.25,278.13 99.82,278.13 97.16,280.8 56.77,280.8 52.96,276.99 1A.2 | v117.73,255.65 118.11,255.27 v135.64,255.27
  Bottom 0.381: v111.25,278.13 111.63,278.51 111.63,281.18 112.4,281.94 116.21,281.94 116.21,267.84 117.73,266.32 v117.73,255.65 | v135.64,255.27 136.02,254.89 136.02,240.79 5B.3
INHIBITX  (via drill 0.35)
  Top 0.381: B6.1 158.12,240.03 163.07,240.03 174.5,251.46 217.93,251.46 v218.31,251.84 | v238.12,120.78 238.51,120.78 238.51,123.06 235.84,125.73 10E.6 | 9A.9 v230.5,266.7
  Bottom 0.381: v218.31,251.84 218.69,252.22 218.69,262.51 9A.9 | v238.12,120.78 238.51,121.16 238.51,237.74 230.5,245.75 v230.5,266.7
INHIBITY  (via drill 0.35)
  Top 0.381: v256.03,22.86 241.94,22.86 241.17,22.1 238.89,22.1 235.84,19.05 10H.6 | v256.03,123.44 258.32,125.73 v259.08,125.73 | 216.41,280.8 v254.51,280.8 | 216.41,280.8 215.26,279.65 9A.1 | v146.69,241.55 154.31,241.55 B6.2 | v146.69,282.7 147.07,282.32 177.93,282.32 178.69,281.56 215.65,281.56 216.41,280.8
  Bottom 0.381: v256.03,123.44 v256.03,22.86 | v259.08,125.73 259.84,126.49 259.84,187.07 254.51,192.41 v254.51,280.8 | v146.69,282.7 v146.69,241.55
INTENSITY0  (via drill 0.35)
  Top 0.381: R19.1 287.65,17.53 289.94,17.53 289.94,11.05 288.8,9.91 262.89,9.91 258.32,5.33 69.34,5.33 66.29,8.38 v62.48,8.38 v28.96,8.38 | v28.96,233.55 52.58,233.55 1B.5
  Bottom 0.381: v62.48,8.38 62.48,13.34 60.58,15.24 1H.12 | v28.96,8.38 v28.96,233.55
INTENSITY1  (via drill 0.35)
  Top 0.381: 65.53,12.57 1H.13 | v70.49,12.57 65.53,12.57 | v70.49,7.24 71.63,6.1 249.17,6.1 254.89,11.81 284.99,11.81 287.65,14.48 R18.1 | v27.81,230.89 52.58,230.89 1B.6 | v27.81,9.52 62.48,9.52 65.53,12.57
  Bottom 0.381: v70.49,7.24 v70.49,12.57 | v27.81,9.52 v27.81,230.89
INTENSITY2  (via drill 0.35)
  Top 0.381: R17.1 289.18,11.43 289.18,14.86 288.04,16 257.94,16 250.7,8.76 184.4,8.76 183.26,7.62 138.68,7.62 136.02,10.29 75.44,10.29 65.91,19.81 60.96,19.81 60.58,20.19 1H.14 | v66.68,228.6 1B.8 | v66.68,60.96 59.06,60.96 56.39,58.29 v56.39,57.53
  Bottom 0.381: v66.68,228.6 66.68,139.83 65.53,138.68 65.53,70.1 66.68,68.96 v66.68,60.96 | v56.39,57.53 56.77,57.15 56.77,24 60.2,20.57 1H.14
INTENSITY3  (via drill 0.35)
  Top 0.381: v64.39,7.24 67.06,4.57 258.7,4.57 262.51,8.38 287.65,8.38 R16.1 | v33.53,226.31 54.1,226.31 54.86,227.08 56.39,227.08 60.2,230.89 1B.9 | v33.53,26.67 56.39,26.67 60.2,22.86 1H.15
  Bottom 0.381: v64.39,7.24 64.39,19.05 60.58,22.86 1H.15 | v33.53,26.67 v33.53,226.31
INVX
  Top 0.381: IC12.13 277.75,148.59 279.65,146.69 279.65,140.21 277.75,138.3 277.75,137.16 R53.2
  Bottom 0.381: Q3.1 278.89,134.49 277.75,134.49 R51.2 277.75,134.87 277.75,137.16 R53.2
INVY
  Top 0.381: Q4.1 282.32,36.96 280.03,39.24 278.89,39.24 R52.2 | IC16.13 279.65,53.72 279.65,41.91 R54.2
  Bottom 0.381: R52.2 278.89,39.62 278.89,41.91 R54.2
LDX2  (via drill 0.35)
  Top 0.381: v98.3,247.27 76.58,247.27 76.2,247.65 56.77,247.65 v56.39,247.27 | v56.39,197.36 58.29,195.45 58.29,189.36 60.2,189.36 1C.11
  Bottom 0.381: 1D.11 60.2,152.4 58.29,154.31 58.29,155.45 59.06,156.21 62.48,156.21 62.48,170.69 61.72,171.45 58.29,171.45 58.29,175.64 60.2,177.55 60.2,188.98 1C.11 | 3B.8 98.3,231.27 98.3,244.22 97.92,244.6 97.92,246.89 v98.3,247.27 | v56.39,197.36 v56.39,247.27
LDXY1  (via drill 0.35)
  Top 0.381: v45.34,42.67 v80.39,42.67 | v45.34,121.92 75.82,121.92 79.63,118.11 2E.11 | v83.06,230.89 93.34,230.89 3B.6 | v46.86,220.98 v81.53,220.98
  Bottom 0.381: v80.39,42.67 80.39,46.86 2G.11 | v45.34,42.67 v45.34,121.92 46.86,123.44 v46.86,220.98 | 2C.11 78.11,186.69 78.11,153.54 77.72,153.16 77.72,123.44 79.25,121.92 82.68,121.92 82.68,120.02 80.77,118.11 2E.11 | v83.06,230.89 83.06,222.5 v81.53,220.98
LDY2  (via drill 0.35)
  Top 0.381: v91.44,251.46 79.25,251.46 78.87,251.08 36.2,251.08 v35.81,251.46 | v35.81,83.82 57.91,83.82 59.06,82.68 60.2,82.68 1F.11
  Bottom 0.381: 1G.11 60.2,47.24 57.53,49.91 57.53,79.63 60.2,82.3 1F.11 | 3B.4 91.44,238.12 v91.44,251.46 | v35.81,83.82 v35.81,251.46
LDZ  (via drill 0.35)
  Top 0.381: v160.02,281.18 159.64,281.56 129.16,281.56 128.4,282.32 124.59,282.32 124.21,282.7 105.92,282.7 105.54,282.32 v95.63,282.32
  Bottom 0.381: v160.02,281.18 160.02,265.18 161.16,265.18 161.93,264.41 6A.8 | v95.63,282.32 95.25,281.94 95.25,278.89 93.34,276.99 3A.2
N$1  (via drill 0.35)
  Top 0.381: v184.79,262.89 178.69,262.89 174.88,266.7 7A.6 | v184.79,268.99 194.69,268.99 8A.5
  Bottom 0.381: v184.79,268.99 v184.79,262.89
N$2  (via drill 0.35)
  Top 0.381: 2A.8 85.34,259.46 v104.78,259.46 | v104.78,220.22 132.97,220.22 133.35,220.6 216.03,220.6 217.55,222.12 v253.37,222.12
  Bottom 0.381: C25.1 258.32,135.64 254.89,132.21 R14.1 253.75,132.97 253.75,221.74 v253.37,222.12 | v104.78,220.22 v104.78,259.46
N$4
  Top 0.381: R22.2 295.27,20.19 297.56,17.91 300.23,17.91 R19.2 | Q2.2 300.99,25.53 307.47,32 310.9,32 318.13,39.24 R21.1
  Bottom 0.381: 300.61,11.43 300.61,8.38 R16.2 | Q2.2 300.99,24 300.61,23.62 300.61,17.91 R19.2 300.61,17.53 300.61,14.86 R18.2 300.61,14.48 300.61,11.43 | 300.61,11.43 R17.2
N$6
  Bottom 0.406: LED1.A R6.1
N$8
  Bottom 0.406: LED3.A R8.1
N$9
  Bottom 0.406: R9.1 LED4.A
N$10
  Top 0.381: IC15.5 R36.2
N$11  (via drill 0.35)
  Top 0.381: IC12.8 281.18,164.97 v281.18,166.5 | R26.1 310.51,140.97 IC11.7
  Bottom 0.381: v281.18,166.5 281.56,166.88 281.56,176.4 R32.1 | 308.61,139.83 308.61,140.21 310.51,142.11 IC11.7 | 308.61,139.83 308.61,128.78 308.23,128.4 C30.1 | 308.61,139.83 306.71,141.73 306.71,143.64 303.66,143.64 294.89,152.4 283.85,152.4 283.08,153.16 283.08,155.83 277.75,161.16 IC12.8
N$12
  Top 0.381: 315.09,21.34 314.33,20.57 R23.1 | 315.09,21.34 316.23,21.34 T2.2 | Q2.3 304.42,24.38 310.51,24.38 T1.1 310.51,24 312.42,24 315.09,21.34
  Bottom 0.381: T1.1 310.51,29.34 309.37,30.48 C28.1
N$13  (via drill 0.35)
  Top 0.381: v120.02,249.56 123.06,249.56 124.97,247.65 4B.23 | v119.63,269.37 116.21,272.8 116.21,275.46 121.16,275.46 4A.14
  Bottom 0.381: v120.02,249.56 119.63,249.94 119.63,262.13 119.25,262.51 119.25,268.99 v119.63,269.37
N$14
  Top 0.381: C27.2 R20.1
  Bottom 0.381: T1.2 308.99,22.48 308.99,21.34 309.37,20.96 309.37,14.1 C27.2
N$15  (via drill 0.35)
  Top 0.381: v26.8,262.89 54.1,262.89 60.2,268.99 1A.10 | v26.8,10.16 24.13,10.16 23.37,9.4 23.37,2.29 310.13,2.29 315.47,7.62 R20.2
  Bottom 0.381: R20.2 315.47,7.62 313.18,9.91 313.18,12.57 C27.1 | v26.8,10.16 v26.8,262.89
N$16
  Top 0.381: 287.27,146.3 289.94,146.3 C39.1 | 287.27,146.3 285.37,146.3 IC12.1 | IC12.3 287.27,148.97 287.27,146.3
N$17
  Top 0.381: C40.1 275.46,144.02 275.46,153.54 277.37,153.54 IC12.11
  Bottom 0.381: IC12.9 277.37,158.5 275.46,156.59 275.46,155.83 277.37,153.92 IC12.11
N$18  (via drill 0.35)
  Top 0.381: IC11.3 306.71,148.59 306.32,148.59 v301.75,144.02
  Bottom 0.381: IC12.10 277.75,156.21 277.75,155.83 284.99,148.59 IC12.2 297.18,148.59 v301.75,144.02
N$19
  Top 0.381: R33.1 301.37,172.59 297.56,168.78 295.27,168.78 294.13,169.93 IC10.2
  Bottom 0.381: IC10.2 294.13,170.31 294.13,176.4 R32.2
N$20
  Bottom 0.381: R31.2 IC10.3
N$21
  Top 0.381: R33.2 301.37,160.02 300.23,161.16 292.61,161.16 291.47,162.31 IC10.6
  Bottom 0.381: IC12.4 291.47,160.02 IC10.6
N$22  (via drill 0.35)
  Top 0.381: v118.49,245.36 124.97,245.36 4B.22
  Bottom 0.381: v118.49,245.36 118.87,245.75 118.87,261.75 118.49,262.13 118.49,270.13 121.16,272.8 4A.13
N$23
  Top 0.381: C41.2 R35.1
  Bottom 0.381: IC11.2 VR1.1 310.51,165.35 308.23,167.64 C41.2
N$24  (via drill 0.35)
  Top 0.381: v127.25,269.37 122.68,269.37 121.54,270.51 4A.12 | v126.87,246.13 126.87,245.75 127.25,245.36 127.25,242.7 125.35,242.7 4B.21
  Bottom 0.381: v127.25,269.37 127.25,246.51 v126.87,246.13
N$25
  Top 0.381: IC15.7 308.99,51.05 307.47,51.05 306.71,50.29 306.71,47.24 287.65,47.24 279.65,55.25 279.65,68.58 IC16.8
  Bottom 0.381: IC15.7 310.51,44.58 | 310.51,44.58 310.51,40.39 308.23,38.1 C43.1 | 310.51,44.58 314.33,44.58 R37.1 | IC16.8 277.75,68.58 281.18,72.01 281.18,84.96 R43.1
N$26  (via drill 0.35)
  Top 0.381: v123.06,252.6 128.02,252.6 128.02,242.32 127.64,241.94 127.25,241.94 125.35,240.03 4B.20
  Bottom 0.381: v123.06,252.6 123.44,252.98 123.44,265.94 121.54,267.84 4A.11
N$27
  Top 0.381: 287.27,54.48 289.94,54.48 C52.1 | 287.27,54.48 286.51,54.48 285.37,53.34 IC16.1 | 287.27,54.48 287.27,56.39 285.37,58.29 IC16.3
N$28
  Top 0.381: IC16.11 275.46,60.96 275.46,49.15 277.37,47.24 C53.1
  Bottom 0.381: IC16.9 275.46,64.01 275.46,62.87 277.37,60.96 IC16.11
N$29
  Top 0.381: IC15.3 307.85,57.15 298.7,48.01 288.04,48.01 283.08,52.96 283.08,55.63 284.99,55.63 IC16.2
  Bottom 0.381: IC16.10 IC16.2
N$30
  Top 0.381: R44.1 301.37,81.15 297.56,77.34 295.27,77.34 294.13,78.49 IC14.2
  Bottom 0.381: IC14.2 294.13,78.87 294.13,84.96 R43.2
N$31
  Bottom 0.381: R42.2 IC14.3
N$32
  Top 0.381: R44.2 301.37,68.58 300.23,69.72 292.61,69.72 291.47,70.87 IC14.6
  Bottom 0.381: IC14.6 291.47,67.06 285.37,60.96 IC16.4
N$33
  Top 0.381: R46.1 305.56,75.06 308.99,75.06 C54.2
  Bottom 0.381: IC15.2 VR2.1 310.51,73.53 309.37,74.68 C54.2
N$34  (via drill 0.35)
  Top 0.381: v96.01,260.6 111.25,260.6 112.4,259.46 152.78,259.46 154.69,257.56 154.69,245.36 149.35,245.36 146.69,242.7 146.3,242.7 145.54,241.94 145.54,240.03 156.97,240.03 160.78,236.22 B6.11
  Bottom 0.381: v96.01,260.6 96.01,268.99 93.34,271.65 3A.4
N$35
  Bottom 0.381: R47.2 282.7,121.92 282.7,128.02 R49.1 282.7,128.4 282.7,129.92 Q3.2
N$36
  Bottom 0.381: 8D/8E.7 195.07,140.97 199.26,145.16 199.26,175.64 200.03,176.4 202.31,176.4 8C/8D.10 202.69,176.78 202.69,179.07 8C/8D.11
N$37
  Bottom 0.381: R48.2 R50.1 Q4.2
N$38
  Top 0.381: Q6.2 298.7,40.01 299.09,40.39 R56.2
  Bottom 0.381: R54.1 Q6.2
N$39
  Bottom 0.381: 290.32,135.25 290.32,137.16 R53.1 | R55.2 297.18,135.25 290.32,135.25 | 290.32,135.25 Q5.2
N$40  (via drill 0.35)
  Top 0.381: v196.98,180.97 197.36,181.36 202.31,181.36 8C/8D.12
  Bottom 0.381: v196.98,180.97 196.98,148.21 195.07,146.3 8D/8E.5
N$41  (via drill 0.35)
  Top 0.381: v220.22,166.5 215.26,166.5 9D.4
  Bottom 0.381: v220.22,166.5 220.22,199.26 9C.13
N$42
  Bottom 0.381: 9E.4 215.26,131.06 216.03,131.83 220.22,131.83 220.22,163.83 222.88,166.5 9D.13
N$43
  Bottom 0.381: 8B.13 198.5,245.36 198.5,270.89 195.07,274.32 8A.3
N$44  (via drill 0.35)
  Top 0.381: 5A.8 135.25,270.51 126.49,270.51 122.68,274.32 v117.35,274.32 | 4A.2 v117.35,278.13
  Bottom 0.381: v117.35,278.13 v117.35,274.32
N$45
  Bottom 0.406: R7.1 LED2.A
N$47  (via drill 0.35)
  Top 0.381: 2A.4 74.3,270.51 v97.16,270.51
  Bottom 0.381: v97.16,270.51 98.3,271.65 100.97,271.65 3A.11
N$48
  Bottom 0.406: R10.1 LED5.K
N$49
  Bottom 0.381: 1A.11 58.29,269.75 58.29,243.46 60.2,241.55 1B.13
N$52
  Top 0.381: C25.2 263.65,136.02 270.89,136.02 C26.1 | Q1.2 D5.A
  Bottom 0.381: 268.99,130.3 267.46,131.83 R14.2 | 268.99,130.3 268.99,125.73 Q1.2 | C26.1 268.99,133.73 268.99,130.3
N$53  (via drill 0.35)
  Top 0.381: v156.21,260.99 155.83,261.37 147.07,261.37 141.73,266.7 5A.9
  Bottom 0.381: v156.21,260.99 156.21,233.17 154.31,231.27 B6.6
N$58
  Top 0.381: 3A.6 96.01,269.37 97.54,269.37 99.06,270.89 99.06,274.32 3A.12
N$59  (via drill 0.35)
  Top 0.381: v200.41,248.41 v180.21,248.41
  Bottom 0.381: v180.21,248.41 180.21,230.5 182.12,228.6 7B.8 | v200.41,248.41 200.41,264.79 202.31,266.7 8A.9
N$60
  Bottom 2.032: IC4.IN 278.13,260.35 285.12,267.34 | 285.12,267.34 290.83,267.34 298.45,259.72 D3.A | 285.12,267.34 278.13,274.32 IC5.IN | D3.A 300.08,259.44 299.42,259.44 297.81,257.83 297.81,236.2 299.42,234.59 300.08,234.59 D4.A | D3.A 306.71,266.06 C4.-
N$61  (via drill 0.35)
  Top 0.381: v169.55,229.36 172.97,229.36 174.5,230.89 7B.6 | v169.55,283.85 184.79,283.85 185.55,283.08 192.41,283.08 v192.79,283.46
  Bottom 0.381: v169.55,283.85 v169.55,229.36 | v192.79,283.46 192.79,278.89 194.69,276.99 8A.2
N$62  (via drill 0.35)
  Top 0.381: 8B.12 204.6,240.79 v207.65,240.79 | v207.65,268.99 202.69,268.99 8A.10
  Bottom 0.381: v207.65,268.99 v207.65,240.79
N$63
  Bottom 0.381: 8B.5 195.07,233.93 197.74,236.6 197.74,264.03 195.07,266.7 8A.6
N$64
  Bottom 0.381: 6H.2 154.31,29.34 156.21,31.24 156.21,50.29 154.31,52.2 6G.7
N$65  (via drill 0.35)
  Top 0.381: v66.68,233.93 60.58,233.93 1B.10 | v66.68,276.61 72.77,276.61 2A.2
  Bottom 0.381: v66.68,276.61 v66.68,233.93
N$67  (via drill 0.35)
  Top 0.381: v75.82,246.51 72.01,246.51 65.53,240.03 56.77,240.03 52.96,236.22 1B.4
  Bottom 0.381: v75.82,246.51 75.82,276.61 2A.1
N$68  (via drill 0.35)
  Top 0.381: 7B.13 188.21,247.27 v202.31,247.27
  Bottom 0.381: v202.31,247.27 202.31,264.03 8A.8
N$69  (via drill 0.35)
  Top 0.381: v179.07,238.89 174.88,238.89 7B.3 | v179.07,282.7 179.45,282.32 194.31,282.32 v194.69,282.7
  Bottom 0.381: v179.07,282.7 v179.07,238.89 | v194.69,282.7 194.69,279.65 8A.1
N$72  (via drill 0.35)
  Top 0.381: v184.4,271.65 194.69,271.65 8A.4
  Bottom 0.381: v184.4,271.65 184.4,271.27 183.64,270.51 180.21,270.51 180.21,283.08 179.45,283.85 176.78,283.85 176.78,276.23 174.88,274.32 7A.3
N$73  (via drill 0.35)
  Top 0.381: v189.74,231.27 194.69,231.27 8B.6 | v189.74,278.13 198.88,278.13 200.03,276.99 202.31,276.99 8A.13
  Bottom 0.381: v189.74,278.13 v189.74,231.27
N$74  (via drill 0.35)
  Top 0.381: v204.6,261.75 188.59,261.75 186.31,264.03 182.5,264.03 7A.8
  Bottom 0.381: v204.6,261.75 204.6,272.41 202.69,274.32 8A.12
N$75
  Top 0.381: 7A.12 182.88,274.32 189.36,280.8 197.36,280.8 200.03,278.13 204.6,278.13 204.6,273.94 202.69,272.03 8A.11
N$79  (via drill 0.35)
  Top 0.381: v217.93,91.44 221.74,95.25 9F.13
  Bottom 0.381: v217.93,91.44 217.93,62.48 215.26,59.82 9G.4
N$80
  Bottom 0.381: 9H.4 215.26,24.38 216.03,25.15 220.22,25.15 220.22,57.15 222.88,59.82 9G.13
N$81
  Top 0.381: 10H.2 235.84,29.34 238.12,29.34 239.65,30.86 239.65,51.82 235.84,51.82 10G.7
N$82
  Top 0.381: 10H.3 235.84,26.67 237.74,28.58 238.51,28.58 240.41,30.48 240.41,54.48 235.84,54.48 10G.6
N$83  (via drill 0.35)
  Top 0.381: 10G.5 v238.89,57.15
  Bottom 0.381: v238.89,57.15 238.89,50.29 233.55,44.96 233.55,26.29 235.46,24.38 10H.4
N$84
  Top 0.381: 10F.7 238.89,87.63 238.89,67.82 235.84,64.77 10G.2
N$85  (via drill 0.35)
  Top 0.381: v229.36,62.48 235.46,62.48 10G.3 | v229.36,89.92 235.46,89.92 10F.6
  Bottom 0.381: v229.36,89.92 v229.36,62.48
N$86  (via drill 0.35)
  Top 0.381: v228.22,59.82 235.46,59.82 10G.4 | v228.22,92.58 235.46,92.58 10F.5
  Bottom 0.381: v228.22,92.58 v228.22,59.82
N$87
  Top 0.381: 10E.2 235.84,136.02 237.74,137.92 237.74,158.5 235.84,158.5 10D.7
N$88
  Top 0.381: 10E.3 235.84,133.35 238.51,136.02 238.51,161.16 235.84,161.16 10D.6
N$89
  Bottom 0.381: 10E.4 235.46,131.06 233.55,132.97 233.55,151.64 237.74,155.83 237.74,161.93 235.84,163.83 10D.5
N$90
  Top 0.381: 10C.7 237.74,194.31 237.74,173.36 235.84,171.45 10D.2
N$91  (via drill 0.35)
  Top 0.381: v236.6,190.12 236.22,190.5 234.31,190.5 233.55,191.26 233.55,196.6 235.46,196.6 10C.6
  Bottom 0.381: 10D.3 237.74,171.07 237.74,188.98 v236.6,190.12
N$92  (via drill 0.35)
  Top 0.381: v229.36,166.5 235.46,166.5 10D.4 | v229.36,199.26 235.46,199.26 10C.5
  Bottom 0.381: v229.36,199.26 v229.36,166.5
N$97
  Top 0.381: 5B.8 141.73,228.6 143.64,230.5 151.26,230.5 154.31,233.55 B6.5
N$99
  Bottom 0.381: 5B.6 138.68,235.84 138.68,266.32 5A.10
N$101
  Bottom 0.381: 3G.13 100.97,59.82 102.87,61.72 102.87,70.1 97.54,75.44 97.54,94.49 100.97,97.92 3F.14
N$102
  Bottom 0.381: 3H.13 100.97,24.38 100.2,25.15 99.06,25.15 99.06,60.2 100.97,62.1 3G.14
N$104  (via drill 0.35)
  Top 0.381: v99.06,281.18 99.44,281.56 112.01,281.56 112.4,281.94 123.83,281.94 127.64,278.13 135.25,278.13 138.68,274.7 138.68,270.51 145.54,270.51 153.92,262.13 v156.59,262.13
  Bottom 0.381: v99.06,281.18 99.06,278.89 100.97,276.99 3A.13 | v156.59,262.13 158.88,259.84 158.88,231.65 B6.8
N$111  (via drill 0.35)
  Top 0.381: v102.87,237.74 103.25,238.12 v107.82,238.12 | v135.64,258.32 v109.73,258.32
  Bottom 0.381: v102.87,237.74 102.87,234.7 101.73,234.7 100.97,233.93 3B.10 | v107.82,238.12 107.82,256.41 v109.73,258.32 | v135.64,258.32 135.64,262.13 137.92,264.41 137.92,270.89 141.35,274.32 5A.12
N$112  (via drill 0.35)
  Top 0.381: v102.49,256.41 116.97,256.41 117.35,256.79 132.97,256.79 v133.35,256.41
  Bottom 0.381: v102.49,256.41 102.87,256.03 102.87,240.79 100.97,238.89 3B.12 | v133.35,256.41 134.49,257.56 134.49,262.13 137.16,264.79 137.16,272.41 5A.13
N$113  (via drill 0.35)
  Top 0.381: v97.16,262.89 97.54,262.51 111.63,262.51 112.78,261.37 133.73,261.37 136.02,263.65 v136.02,265.18
  Bottom 0.381: v97.16,262.89 97.16,242.32 94.11,242.32 93.34,241.55 3B.2 | v136.02,265.18 136.02,274.7 134.11,276.61 5A.2
N$114
  Top 0.381: 5A.1 134.49,278.89 135.64,278.89 139.45,275.08 139.45,272.03 141.35,272.03 5A.11
N$115
  Top 0.381: IC13.14 292.99,99.06 294.13,97.92 297.94,97.92 299.09,96.77 R39.1
  Bottom 0.381: R39.1 R38.1
N$116
  Top 0.381: C45.1 297.94,99.06 292.99,104.01 IC13.16
N$118
  Bottom 0.381: IC13.15 296.42,97.92 296.42,96.77 R40.1
N$120
  Top 0.381: C32.1 297.94,190.5 292.99,195.45 IC9.16
N$121
  Top 0.381: IC9.14 292.99,190.5 294.13,189.36 297.94,189.36 299.09,188.21 R28.1
  Bottom 0.381: R28.1 R27.1
N$122
  Bottom 0.381: IC9.15 296.42,189.36 296.42,188.21 R29.1
N$123
  Bottom 0.406: LED6.K R11.1
N$124
  Top 0.381: R25.2 302.89,142.49 305.18,142.49 IC11.5
N$129
  Bottom 0.381: 3C.14 100.97,204.98 98.3,204.98 97.16,203.84 97.16,166.5 100.97,166.5 3D.13
N$137  (via drill 0.35)
  Top 0.381: v105.92,258.32 81.53,258.32 73.15,266.7 2A.6 | v108.59,280.42 113.54,280.42 4A.1
  Bottom 0.381: v105.92,258.32 108.59,260.99 v108.59,280.42
N$142
  Bottom 0.381: 6G.2 156.97,67.44 156.97,84.96 6F.7
N$143  (via drill 0.35)
  Top 0.381: v148.97,62.48 154.31,62.48 6G.3 | v148.97,89.92 154.31,89.92 6F.6
  Bottom 0.381: v148.97,89.92 v148.97,62.48
N$144
  Bottom 0.381: 6G.4 154.31,59.82 157.73,63.25 157.73,89.15 154.31,92.58 6F.5
N$146
  Bottom 0.381: 6H.3 156.97,29.34 156.97,51.82 154.31,54.48 6G.6
N$147
  Bottom 0.381: 6G.5 157.73,53.72 157.73,26.29 155.83,24.38 154.31,24.38 6H.4
N$155  (via drill 0.35)
  Top 0.381: v96.01,168.78 100.97,168.78 3D.14
  Bottom 0.381: v96.01,168.78 96.39,168.4 96.39,166.12 96.77,165.74 96.77,131.83 100.2,131.83 100.97,131.06 3E.13
N$168  (via drill 0.35)
  Top 0.381: v207.65,69.72 202.69,69.72 8F/8G.10
  Bottom 0.381: v207.65,69.72 207.65,25.91 203.45,25.91 195.07,34.29 8G/8H.7 | 8F/8G.11 202.69,72.39 202.69,70.1 8F/8G.10
N$169
  Bottom 0.381: 8F/8G.12 198.88,71.25 198.88,43.43 195.07,39.62 8G/8H.5
N$187
  Bottom 0.381: 6D.4 154.31,166.5 157.73,169.93 157.73,195.07 156.21,196.6 156.21,197.36 154.31,199.26 6C.5
N$188
  Bottom 0.381: 6D.3 154.31,169.16 155.83,169.16 156.97,170.31 156.97,194.31 154.31,196.98 6C.6
N$189
  Bottom 0.381: 6D.2 156.21,173.36 156.21,192.41 6C.7
N$190
  Bottom 0.381: 6D.5 157.73,160.4 157.73,131.83 155.07,131.83 154.31,131.06 6E.4
N$191
  Bottom 0.381: 6E.3 156.97,136.02 156.97,158.5 154.31,161.16 6D.6
N$192
  Bottom 0.381: 6E.2 154.31,136.02 156.21,137.92 156.21,156.97 154.31,158.88 6D.7
NINVX  (via drill 0.35)
  Top 0.381: 292.99,131.83 293.75,131.06 293.75,125.73 R57.1 | 292.99,131.83 Q5.1 | v285.37,134.87 288.42,131.83 292.99,131.83
  Bottom 0.381: IC12.12 285.37,143.26 v285.37,134.87
NINVY
  Top 0.381: R58.1 295.27,35.81 292.99,38.1 Q6.1
  Bottom 0.381: IC16.12 277.75,58.29 292.99,43.05 292.99,38.1 Q6.1
NORMALX  (via drill 0.35)
  Top 0.381: 5E.1 139.45,132.97 139.45,129.54 153.16,129.54 154.31,128.4 6E.5 | v102.87,208.41 104.01,209.55 5C.1
  Bottom 0.381: 3C.13 102.87,203.84 v102.87,208.41 | 136.02,176.02 5D.1 | 136.02,176.02 136.02,207.65 134.11,209.55 5C.1 | 136.02,176.02 137.54,174.5 137.54,150.11 134.87,147.45 134.87,139.45 134.11,138.68 5E.1
NORMALY  (via drill 0.35)
  Top 0.381: v128.78,95.25 3F.13 | 5F.1 v128.78,102.87 | v133.73,43.05 v136.02,43.05 v147.83,43.05 | v147.83,20.57 153.54,20.57 154.31,21.34 6H.5 | v104.01,70.1 104.39,69.72 110.87,69.72 111.63,68.96 111.63,67.06 114.68,67.06 120.02,72.39 122.68,72.39 127.64,67.44 133.73,67.44 5G.1
  Bottom 0.381: v128.78,102.87 v128.78,95.25 | v133.73,43.05 133.73,32 5H.1 | v136.02,43.05 136.02,65.15 134.11,67.06 5G.1 | v147.83,43.05 v147.83,20.57 | 3F.13 98.3,92.58 98.3,75.82 v104.01,70.1
OFFDRAWSPEED  (via drill 0.35)
  Top 0.381: 7B.9 185.17,228.22 192.79,228.22 193.93,227.08 211.07,227.08 214.88,230.89 215.26,230.89 9B.6 | v177.93,266.7 7A.9
  Bottom 0.381: v177.93,266.7 177.93,230.5 181.36,227.08 184.4,227.08 184.4,228.98 7B.9
P1
  Top 0.381: R1.2 107.44,266.7 108.59,265.56 113.54,265.56 4A.7 113.92,265.56 121.16,265.56 4A.10
  Bottom 0.381: 4A.9 121.16,262.89 121.16,265.18 4A.10
P2  (via drill 0.35)  (3 unrouted)
  Top 0.381: v200.41,175.26 204.98,175.26 208.79,179.07 | v157.35,196.98 160.02,194.31 160.02,190.5 196.22,190.5 200.41,186.31 200.41,182.88 204.98,182.88 | 208.79,179.07 204.98,182.88 | 208.79,179.07 R2.2 | 204.98,182.88 217.17,182.88 217.17,193.55 221.74,198.12 224.03,198.12 228.6,202.69 233.93,202.69 235.46,204.22 10C.3
  Bottom 0.381: 8D/8E.12 200.41,148.21 v200.41,175.26 | v157.35,196.98 157.35,203.45 155.07,203.45 154.31,204.22 6C.3
P3  (via drill 0.35)  (3 unrouted)
  Top 0.381: v209.93,39.62 202.69,39.62 8G/8H.12 | v155.83,114.3 162.69,114.3 164.59,116.2 v196.22,116.2 | v196.22,97.92 208.79,97.92 R3.2 209.17,97.92 210.31,99.06 224.03,99.06 224.79,98.3 235.08,98.3 10F.3
  Bottom 0.381: v209.93,39.62 210.31,40.01 210.31,96.39 R3.2 | v155.83,114.3 155.83,105.92 156.21,105.54 156.21,99.82 154.31,97.92 6F.3 | v196.22,97.92 v196.22,116.2
PROCESSOROVERRIDE  (via drill 0.35)
  Top 0.381: v9.65,177.17 v20.96,177.17 | v20.96,248.41 v94.87,248.41
  Bottom 0.381: v94.87,248.41 94.87,260.99 95.25,261.37 95.25,268.22 94.11,268.22 93.34,268.99 3A.5 | v20.96,177.17 v20.96,248.41 | v9.65,177.17 9.65,174.5 6.98,171.83 5.08,171.83 P1.E
RESETVRAMPC  (via drill 0.35)
  Top 0.381: v98.3,249.56 83.82,249.56 83.44,249.17 21.72,249.17 21.34,249.56 v18.67,249.56 | v18.67,171.83 5.08,171.83 P1.5
  Bottom 0.381: v98.3,249.56 98.3,267.84 96.01,270.13 96.01,270.89 96.77,271.65 96.77,283.46 95.25,283.46 94.49,282.7 94.49,280.8 93.34,279.65 3A.1 | v18.67,171.83 v18.67,249.56
ROTATE  (via drill 0.35)
  Top 0.381: v147.83,276.61 154.31,276.61 6A.2 | v147.83,246.89 147.45,246.51 136.78,246.51 134.11,243.84 5B.1
  Bottom 0.381: 5B.4 133.73,236.22 131.83,238.12 131.83,241.94 133.73,243.84 5B.1 | v147.83,246.89 v147.83,276.61
ROTCLK  (via drill 0.35)
  Top 0.381: v179.07,20.19 178.31,20.19 178.31,18.67 179.07,17.91 182.12,17.91 7H.9 | v146.69,238.51 141.73,238.51 5B.12 | v183.64,184.78 v146.69,184.78 | v179.07,124.59 182.12,124.59 7E.9 | v179.07,158.88 180.21,160.02 7D.9
  Bottom 0.381: v179.07,20.19 179.45,20.57 179.45,50.67 | 179.45,50.67 182.12,53.34 7G.9 | 180.21,86.87 7F.9 | 180.21,86.87 180.21,77.34 179.45,76.58 179.45,50.67 | 7E.9 184.4,122.3 184.4,106.3 180.21,102.11 180.21,86.87 | 7D.9 182.12,160.02 180.21,161.93 180.21,173.74 183.64,177.17 v183.64,184.78 183.64,192.02 184.4,192.79 184.4,193.55 182.5,195.45 7C.9 | v146.69,184.78 v146.69,238.51 | v179.07,158.88 v179.07,124.59
ROTMODE  (via drill 0.35)
  Top 0.381: v179.45,195.45 174.88,195.45 7C.6 | v172.59,260.99 165.35,268.22 162.69,268.22 161.93,268.99 6A.10
  Bottom 0.381: 177.17,51.05 174.88,53.34 7G.6 | 177.17,51.05 177.93,50.29 177.93,20.96 174.88,17.91 7H.6 | 176.78,86.87 177.17,86.49 177.17,51.05 | 176.78,86.87 174.88,88.77 7F.6 | 176.78,122.3 7E.6 | 176.78,86.87 176.78,122.3 | 176.78,158.12 174.88,160.02 7D.6 | 176.78,122.3 176.78,158.12 | v179.45,195.45 179.07,195.07 179.07,174.88 177.93,173.74 177.93,159.26 176.78,158.12 | v172.59,260.99 172.59,233.17 173.36,232.41 177.17,232.41 177.17,203.07 176.02,201.93 172.59,201.93 172.59,197.74 174.5,195.83 7C.6
SHCON  (via drill 0.35)
  Top 0.381: R15.2 267.46,129.54 268.61,130.68 270.89,130.68 C26.2 | v278.51,126.87 271.27,126.87 Q1.1 | v264.8,160.02 v281.56,160.02
  Bottom 0.381: IC12.5 284.99,156.21 284.99,158.5 IC12.6 283.85,160.02 v281.56,160.02 | IC16.5 284.99,63.63 284.99,65.91 IC16.6 287.27,68.2 287.27,115.44 278.51,124.21 v278.51,126.87 | Q1.1 271.27,127.25 271.27,130.68 C26.2 | v264.8,160.02 264.8,131.83 267.08,129.54 R15.2
SUBTRACT
  Top 0.381: B6.13 161.93,241.55 161.16,242.32 160.78,242.32 157.73,245.36 157.73,271.65 154.31,271.65 6A.4
TOPPLANE
  pour Top (isolate 0.381): 229.24,285.75 314.96,285.75 324.49,276.23 328.93,271.78 328.93,267.34 328.93,10.16 328.3,9.52 320.04,1.27 254,1.27 254,225.43 253.37,226.06 229.24,250.19 229.24,251.46
U/DX  (via drill 0.35)
  Top 0.381: v233.17,131.83 227.84,137.16 221.74,137.16 219.07,134.49 219.07,128.4 215.26,128.4 9E.5
  Bottom 0.381: 217.17,161.93 217.17,155.45 213.36,151.64 213.36,130.3 215.26,128.4 9E.5 | 9D.5 217.17,161.93 | 217.17,161.93 217.17,174.5 215.26,176.4 215.26,177.17 217.17,179.07 217.17,197.36 215.26,199.26 9C.5 | 10E.5 233.17,130.68 v233.17,131.83
U/DY  (via drill 0.35)
  Top 0.381: v229.36,21.72 235.46,21.72 10H.5 | v213.36,35.05 v229.36,35.05
  Bottom 0.381: 217.17,55.25 217.17,48.77 213.36,44.96 v213.36,35.05 213.36,23.62 215.26,21.72 9H.5 | 9G.5 217.17,55.25 | 217.17,55.25 219.07,57.15 219.07,92.58 215.26,92.58 9F.5 | v229.36,35.05 v229.36,21.72
VCC  (via drill 0.35, 0.55)
  Top 0.381: T2.1 319.66,21.34 319.66,19.05 298.32,19.05 294.51,22.86 257.56,22.86 248.79,31.62 243.46,31.62 10H.16 | v5.08,185.55 5.08,185.42
  Top 1.016: 64.14,288.29 v64.14,284.48 | 83.19,288.29 84.46,287.02 v84.46,284.48 | 103.51,288.29 104.78,287.02 v104.78,284.48 | 125.09,288.29 v125.09,284.48 | 145.42,288.29 v145.42,284.48 | 165.74,288.29 v165.74,284.48 | 184.79,288.29 186.06,287.02 v186.06,284.48 | 206.38,288.29 v206.38,284.48 | 225.43,288.29 226.69,287.02 v226.69,284.48 | 241.94,288.29 v241.94,284.48
  Top 2.54: P1.2 4.83,185.42 P1.1 | X2.8 318.13,259.72 X2.7
  Top 5.08: 4.83,185.42 5.08,185.42 10.16,185.42 15.24,190.5 15.24,277.5 26.04,288.29 64.14,288.29 83.19,288.29 103.51,288.29 125.09,288.29 145.42,288.29 165.74,288.29 184.79,288.29 206.38,288.29 225.43,288.29 241.94,288.29 315.6,288.29 326.39,277.5 326.39,259.72 318.13,259.72
  Bottom 0.381: T2.1 R21.2 318.13,28.96 314.33,32.77 R23.2 | v5.08,185.55 4.83,185.55
  Bottom 1.016: v64.14,284.48 64.14,279.4 | 64.14,279.4 1A.14 | 64.14,279.4 64.14,243.84 | 64.14,243.84 64.14,218.44 | 64.14,218.44 64.14,212.09 | 64.14,212.09 64.14,175.26 | 64.14,175.26 64.14,105.41 | 64.14,105.41 64.14,76.2 | 64.14,76.2 64.14,69.85 | 64.14,69.85 64.14,35.56 1H.20 | 1G.20 64.14,69.85 | C20.1 64.14,76.2 | 1F.20 64.14,105.41 | 1D.20 64.14,175.26 | 1C.20 64.14,212.09 | 1B.14 64.14,243.84 | v84.46,284.48 84.46,279.4 | 84.46,279.4 2A.14 | 84.46,279.4 84.46,243.84 | 84.46,243.84 84.46,218.44 | 84.46,218.44 84.46,212.09 | 84.46,212.09 84.46,199.39 | 84.46,199.39 84.46,172.72 | 84.46,172.72 84.46,163.83 | 84.46,163.83 84.46,140.97 | 84.46,140.97 84.46,128.27 | 84.46,128.27 84.46,101.6 | 84.46,101.6 84.46,92.71 | 84.46,92.71 84.46,76.2 | 84.46,76.2 84.46,69.85 | 84.46,69.85 84.46,57.15 | 84.46,57.15 84.46,30.48 | 84.46,30.48 2H.14 | 2G.20 84.46,69.85 | C21.1 84.46,76.2 | 2F.14 84.46,101.6 | 2E.20 84.46,140.97 | 2D.14 84.46,172.72 | 2C.20 84.46,212.09 | C11.1 84.46,218.44 | C10.1 64.14,218.44 | 2B.14 84.46,243.84 | v104.78,284.48 104.78,279.4 | 104.78,279.4 R1.1 | 104.78,279.4 3A.14 | 104.78,279.4 104.78,261.62 100.97,257.81 3B.14 | 84.46,199.39 3C.5 | 84.46,218.44 C12.1 | 84.46,163.83 3D.5 | 84.46,128.27 3E.5 | 84.46,92.71 3F.5 | C22.1 84.46,76.2 | 84.46,57.15 3G.5 | 3H.5 89.54,21.59 84.46,26.67 84.46,30.48 | 4A.16 125.09,280.67 | 125.09,280.67 v125.09,284.48 | 125.09,280.67 125.09,252.73 | 125.09,252.73 4B.24 | 125.09,252.73 120.02,247.65 120.02,215.9 | 120.02,215.9 C13.1 | 120.02,215.9 126.37,209.55 126.37,190.5 | 4G/4H.14 126.37,48.26 126.37,83.82 | 126.37,190.5 126.37,154.94 | 126.37,154.94 126.37,91.44 | 126.37,91.44 126.37,83.82 | 4F/4G.14 126.37,83.82 | C23.1 126.37,91.44
  Bottom 1.016: 4D/4E.14 126.37,154.94 | 4C/4D.14 126.37,190.5 | v145.42,284.48 145.42,279.4 | 145.42,279.4 5A.14 | 145.42,279.4 145.42,243.84 | 145.42,243.84 145.42,218.44 | 145.42,218.44 145.42,209.55 | 145.42,209.55 145.42,173.99 | 145.42,173.99 145.42,138.43 | 145.42,138.43 145.42,102.87 | 145.42,102.87 145.42,76.2 | 145.42,76.2 145.42,67.31 | 145.42,67.31 145.42,31.75 5H.16 | 5G.16 145.42,67.31 | C24.1 145.42,76.2 | 5F.16 145.42,102.87 | 5E.16 145.42,138.43 | 5D.16 145.42,173.99 | 5C.16 145.42,209.55 | C14.1 145.42,218.44 | 5B.14 145.42,243.84 | v165.74,284.48 165.74,279.4 | 165.74,279.4 6A.14 | 165.74,279.4 165.74,243.84 | 165.74,243.84 165.74,218.44 | 165.74,218.44 165.74,209.55 | 165.74,209.55 165.74,173.99 | 165.74,173.99 165.74,138.43 | 165.74,138.43 165.74,102.87 | 165.74,102.87 165.74,76.2 | 165.74,76.2 165.74,67.31 | 165.74,67.31 165.74,31.75 6H.16 | 6G.16 165.74,67.31 | C55.1 165.74,76.2 | 6F.16 165.74,102.87 | 6E.16 165.74,138.43 | 6D.16 165.74,173.99 | 6C.16 165.74,209.55 | C15.1 165.74,218.44 | B6.14 165.74,243.84 | v186.06,284.48 186.06,279.4 | 186.06,279.4 7A.14 | 186.06,279.4 186.06,243.84 | 186.06,243.84 186.06,218.44 | 186.06,218.44 186.06,208.28 | 186.06,208.28 186.06,172.72 | 186.06,172.72 186.06,137.16 | 186.06,137.16 186.06,101.6 | 186.06,101.6 186.06,76.2 | 186.06,76.2 186.06,66.04 | 186.06,66.04 186.06,30.48 7H.14 | 7G.14 186.06,66.04 | C56.1 186.06,76.2 | 7F.14 186.06,101.6 | 7E.14 186.06,137.16 | 7D.14 186.06,172.72 | 7C.14 186.06,208.28 | C16.1 186.06,218.44 | 7B.14 186.06,243.84 | v206.38,284.48 206.38,279.4 | 206.38,279.4 8A.14 | R3.1 206.38,85.09 | 206.38,279.4 206.38,243.84 | 206.38,243.84 206.38,218.44 | 206.38,218.44 206.38,191.77 | 206.38,191.77 206.38,156.21
  Bottom 1.016: 206.38,156.21 206.38,92.71 | 206.38,92.71 206.38,85.09 | 206.38,85.09 8F/8G.16 | C57.1 206.38,92.71 | 206.38,85.09 206.38,49.53 8G/8H.16 | 8D/8E.16 206.38,156.21 | 8C/8D.16 206.38,191.77 | 206.38,191.77 R2.1 | C17.1 206.38,218.44 | 8B.14 206.38,243.84 | 9A.14 226.69,279.4 | 226.69,279.4 v226.69,284.48 | 226.69,279.4 226.69,243.84 | 226.69,243.84 9B.14 | 226.69,243.84 226.69,218.44 | 226.69,218.44 226.69,209.55 | 226.69,209.55 226.69,173.99 | 226.69,173.99 226.69,138.43 | 226.69,138.43 226.69,102.87 | 226.69,102.87 226.69,76.2 | 226.69,76.2 226.69,67.31 | 226.69,67.31 226.69,31.75 9H.16 | 9G.16 226.69,67.31 | C58.1 226.69,76.2 | 9F.16 226.69,102.87 | 9E.16 226.69,138.43 | 9D.16 226.69,173.99 | 9C.16 226.69,209.55 | C18.1 226.69,218.44 | 10C.16 247.02,209.55 | 247.02,209.55 247.02,218.44 | 247.02,218.44 247.02,231.14 235.27,242.89 235.27,263.21 | v241.94,284.48 241.94,269.57 241.63,269.57 235.27,263.21 | C19.1 247.02,218.44 | 247.02,209.55 247.02,173.99 | 247.02,173.99 247.02,138.43 | 247.02,138.43 247.02,102.87 | 247.02,102.87 247.02,76.2 | 247.02,76.2 247.02,67.31 | 247.02,67.31 247.02,31.75 10H.16 | 10G.16 247.02,67.31 | C59.1 247.02,76.2 | 10D.16 247.02,173.99 | 10E.16 247.02,138.43 | 10F.16 247.02,102.87 | 235.27,263.21 R9.2
  Bottom 2.54: P1.1 4.83,185.55 P1.2
VECTORCOMPLETE
  Top 0.381: B6.9 161.93,231.27 154.69,238.51 154.31,238.51 B6.3
VRAM0  (via drill 0.35)
  Top 0.381: v39.24,15.24 1H.9 | v39.24,102.49 39.62,102.87 1F.2 | v36.96,209.55 1C.2 | v36.96,148.21 5.08,148.21 P1.11
  Bottom 0.381: v39.24,15.24 v39.24,102.49 36.96,104.78 v36.96,148.21 v36.96,209.55
VRAM1  (via drill 0.35)
  Top 0.381: v40.39,17.91 52.58,17.91 1H.8 | v40.39,100.2 52.58,100.2 1F.3 | v38.1,206.88 52.58,206.88 1C.3 | v38.1,144.02 5.08,144.02 P1.12
  Bottom 0.381: v40.39,17.91 v40.39,100.2 40.39,102.87 38.1,105.16 v38.1,144.02 v38.1,206.88
VRAM2  (via drill 0.35)
  Top 0.381: v46.48,20.57 52.58,20.57 1H.7 | 1F.4 52.58,97.54 v46.48,97.54 v41.53,97.54 | v41.53,204.22 52.58,204.22 1C.4 | v41.53,140.21 5.08,140.21 P1.13
  Bottom 0.381: v46.48,97.54 v46.48,20.57 | v41.53,97.54 v41.53,140.21 v41.53,204.22
VRAM3  (via drill 0.35)
  Top 0.381: v47.63,22.86 1H.6 | 1F.5 v47.63,95.25 v42.29,95.25 | v42.67,201.93 1C.5 | v42.67,136.02 5.08,136.02 P1.14
  Bottom 0.381: v47.63,95.25 v47.63,22.86 | v42.67,201.93 v42.67,136.02 42.67,95.63 v42.29,95.25
VRAM4  (via drill 0.35)
  Top 0.381: v56.01,132.21 5.08,132.21 P1.15
  Bottom 0.381: 1G.2 52.96,67.44 55.25,69.72 55.25,96.77 56.01,97.54 v56.01,132.21 56.01,134.87 55.25,135.64 55.25,137.16 55.63,137.54 55.63,196.6 52.96,199.26 1C.6
VRAM5  (via drill 0.35)
  Top 0.381: v20.96,128.02 5.08,128.02 P1.16 | v22.1,196.6 52.58,196.6 1C.7 | v20.96,64.77 1G.3
  Bottom 0.381: v20.96,64.77 v20.96,128.02 22.1,129.16 v22.1,196.6
VRAM6  (via drill 0.35)
  Top 0.381: v18.67,62.48 52.58,62.48 1G.4 | v18.67,124.21 5.08,124.21 P1.17 | v19.81,194.31 1C.8
  Bottom 0.381: v18.67,62.48 v18.67,124.21 19.81,125.35 v19.81,194.31
VRAM7  (via drill 0.35)
  Top 0.381: v54.48,120.4 5.08,120.4 P1.18 | v54.86,97.92 v56.39,96.39
  Bottom 0.381: 54.86,57.53 54.86,35.05 52.96,33.15 1H.2 | 1G.5 54.86,57.53 | 1C.9 52.96,191.64 54.86,189.74 54.86,137.92 54.48,137.54 v54.48,120.4 54.86,120.02 v54.86,97.92 | 54.86,57.53 56.39,59.05 v56.39,96.39
VRAM8  (via drill 0.35)
  Top 0.381: v43.43,57.15 1G.6 | 1D.6 52.58,162.31 v43.82,162.31 v9.65,162.31
  Bottom 0.381: v43.43,57.15 43.43,135.25 43.82,135.64 v43.82,162.31 | v9.65,162.31 9.65,150.11 6.98,150.11 5.08,148.21 P1.M
VRAM9  (via drill 0.35)
  Top 0.381: v31.24,54.86 52.58,54.86 1G.7 | 1D.7 v31.24,160.02 | v5.08,145.92 v31.24,145.92
  Bottom 0.381: v31.24,160.02 v31.24,145.92 v31.24,54.86 | v5.08,145.92 5.08,144.4 P1.N
VRAM10  (via drill 0.35)
  Top 0.381: v32.39,52.2 52.58,52.2 1G.8 | 1D.8 52.58,157.35 v32.39,157.35 v10.8,157.35
  Bottom 0.381: v32.39,157.35 v32.39,52.2 | v10.8,157.35 10.8,142.49 7.37,142.49 5.08,140.21 P1.P
VRAM11  (via drill 0.35)
  Top 0.381: v44.2,49.53 1G.9 | 1D.9 52.58,154.69 v44.96,154.69 v11.94,154.69
  Bottom 0.381: v44.2,49.53 44.58,49.91 44.58,121.16 44.2,121.54 44.2,134.87 44.96,135.64 v44.96,154.69 | P1.R 6.98,138.3 11.94,138.3 v11.94,154.69
VRAMPC  (via drill 0.35)
  Top 0.381: v115.82,266.7 v131.83,266.7 | v113.16,252.6 112.78,252.98 79.25,252.98 78.87,253.37 v23.24,253.37 | v23.24,176.02 5.08,176.02 P1.4
  Bottom 0.381: v131.83,266.7 131.83,272.41 133.73,274.32 5A.3 | v115.82,266.7 115.82,256.03 113.16,253.37 v113.16,252.6 | v23.24,176.02 v23.24,253.37
XBRM0  (via drill 0.35)
  Top 0.381: v196.98,205.74 7C.13
  Bottom 0.381: v196.98,205.74 196.98,186.31 195.07,184.4 8C/8D.4
XBRM1
  Top 0.381: 8C/8D.1 195.07,192.02 195.07,193.55 196.6,195.07 196.6,203.07 182.5,203.07 7C.12
XBRM2  (via drill 0.35)
  Top 0.381: v195.45,200.79 182.5,200.79 7C.11
  Bottom 0.381: v195.45,200.79 195.83,201.17 195.83,206.12 196.6,206.88 199.64,206.88 199.64,189.36 202.31,186.69 8C/8D.14
XBRM3  (via drill 0.35)
  Top 0.381: v184.4,204.22 197.36,204.22 197.36,194.31 202.31,189.36 8C/8D.15
  Bottom 0.381: 7D.1 176.02,174.12 176.02,181.36 178.31,183.64 178.31,195.83 180.59,198.12 7C.10 182.5,198.12 184.4,200.03 v184.4,204.22
XBRM4  (via drill 0.35)
  Top 0.381: v184.79,174.12 184.79,172.59 182.5,170.31 7D.13 | v184.79,188.98 194.69,188.98 8C/8D.2
  Bottom 0.381: v184.79,188.98 v184.79,174.12